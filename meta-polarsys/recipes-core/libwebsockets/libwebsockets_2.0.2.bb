require libwebsockets.inc

PV = "2.0.2"

SRC_URI[sha256sum] = "43865604debd06686ac4d8d0783976c4e10dd519ccd5c94e1b53878ec6178a59"
